
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-my_defconfig-is-created.patch"

